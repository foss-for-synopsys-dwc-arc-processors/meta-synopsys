EXTRA_OECONF_append_libc-uclibc = " --disable-rsh --disable-rcp --disable-rlogin "
