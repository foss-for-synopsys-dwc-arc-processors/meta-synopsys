require recipes-core/glibc/glibc-locale.inc
INSANE_SKIP_${PN} = "file-rdeps"
INSANE_SKIP_${PN}-dev = "file-rdeps"


