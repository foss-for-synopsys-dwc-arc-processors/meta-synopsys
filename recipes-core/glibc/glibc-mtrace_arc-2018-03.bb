require recipes-core/glibc/glibc-mtrace.inc
INSANE_SKIP_${PN} = "file-rdeps"
INSANE_SKIP_${PN}-dev = "file-rdeps"


