require recipes-core/glibc/glibc-scripts.inc
INSANE_SKIP_${PN} = "file-rdeps"
INSANE_SKIP_${PN}-dev = "file-rdeps"

