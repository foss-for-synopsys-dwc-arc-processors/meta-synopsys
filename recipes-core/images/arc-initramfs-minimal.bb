IMAGE_LINGUAS = ""
IMAGE_FSTYPES += "${INITRAMFS_FSTYPES}"
inherit core-image
