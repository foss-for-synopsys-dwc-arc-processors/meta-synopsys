IMAGE_FSTYPES = "${INITRAMFS_FSTYPES}"
