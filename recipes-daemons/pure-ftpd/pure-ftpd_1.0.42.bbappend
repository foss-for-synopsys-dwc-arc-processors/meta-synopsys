FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}-${PV}:"

SRC_URI += "file://0001-getloadavg-Remove-hardcoded-cflags.patch"
