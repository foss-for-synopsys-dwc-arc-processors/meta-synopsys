require recipes-devtools/binutils/binutils.inc
require binutils-${PV}.inc
require recipes-devtools/binutils/binutils-cross.inc
