require gcc-${PV}.inc
require recipes-devtools/gcc/gcc-cross-canadian.inc
