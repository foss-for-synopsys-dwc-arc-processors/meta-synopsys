require gcc-${PV}.inc
require recipes-devtools/gcc/gcc-cross.inc
