require recipes-devtools/gcc/gcc-${PV}.inc
require recipes-devtools/gcc/gcc-runtime.inc

RUNTIMELIBITM:arc32 = ""
RUNTIMELIBITM:arc64 = ""
