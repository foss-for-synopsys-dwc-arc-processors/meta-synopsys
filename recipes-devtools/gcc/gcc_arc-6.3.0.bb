require gcc-${PV}.inc
require recipes-devtools/gcc/gcc-target.inc

BBCLASSEXTEND = "nativesdk"
