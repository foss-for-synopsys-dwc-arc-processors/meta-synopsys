require gcc-${PV}.inc
require recipes-devtools/gcc/libgcc-initial.inc
