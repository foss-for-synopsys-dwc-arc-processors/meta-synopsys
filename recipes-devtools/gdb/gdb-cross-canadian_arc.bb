require recipes-devtools/gdb/gdb-common.inc
require recipes-devtools/gdb/gdb-cross-canadian.inc
require recipes-devtools/gdb/gdb-${PV}.inc
