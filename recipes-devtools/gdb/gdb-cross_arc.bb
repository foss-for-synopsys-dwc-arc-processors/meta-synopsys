require recipes-devtools/gdb/gdb-cross.inc
require recipes-devtools/gdb/gdb-${PV}.inc
