PACKAGECONFIG[wayland] += " wayland-protocols"
PACKAGECONFIG_append = " gallium"
GALLIUMDRIVERS_append = ",imx,etnaviv"

