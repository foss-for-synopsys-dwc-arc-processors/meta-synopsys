FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append += "\
    file://dvi-i-1-270.cfg \
"

