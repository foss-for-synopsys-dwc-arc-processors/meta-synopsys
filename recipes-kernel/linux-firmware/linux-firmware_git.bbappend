FILES_${PN}-ath9k += " \
    /lib/firmware/ath9k_htc/htc*.fw \
"

