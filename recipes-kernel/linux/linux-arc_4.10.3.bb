require linux-arc.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=d7810fab7487fb0aad327b76f1be7cd7"
SRC_URI[sha256sum] = "194165f6bf8ed6ad81eb2231e1cdf497d70a07a489d5f3161544f61a198528d4"
