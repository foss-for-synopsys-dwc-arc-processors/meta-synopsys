require linux-arc.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=d7810fab7487fb0aad327b76f1be7cd7"
SRC_URI[sha256sum] = "a1dc15e4dba9a385c4112903da81c01f412b36420feefa7771797073f5352a8f"
