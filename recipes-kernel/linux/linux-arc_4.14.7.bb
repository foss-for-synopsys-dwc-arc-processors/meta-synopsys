require linux-arc.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=d7810fab7487fb0aad327b76f1be7cd7"
SRC_URI[sha256sum] = "14ceb78a42d03c71f1a18cafb2d3b26eee77e41b73dd2a14058678d53b2129ec"
