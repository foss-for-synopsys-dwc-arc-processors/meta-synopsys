require linux-arc.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=bbea815ee2795b2f4230826c0c6b8814"
SRC_URI[sha256sum] = "36c6d1360db9eab40270db6d292c259dd34d3dc06049d64afe3e4cfafb8562d3"
