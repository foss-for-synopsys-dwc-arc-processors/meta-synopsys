require linux-arc.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=bbea815ee2795b2f4230826c0c6b8814"
SRC_URI[sha256sum] = "fb090a3680eddf6f10bf895bc3075bd3f830e3d2429ce469982db5a28df647bd"
