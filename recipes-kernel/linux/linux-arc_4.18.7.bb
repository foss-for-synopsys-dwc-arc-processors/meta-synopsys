require linux-arc.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=bbea815ee2795b2f4230826c0c6b8814"
SRC_URI[sha256sum] = "f03b425e262a71e5079736706233a4e9afaf77c8462b552b4d6db2d33f5af731"
