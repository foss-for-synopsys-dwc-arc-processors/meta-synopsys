require linux-arc.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=d7810fab7487fb0aad327b76f1be7cd7"
SRC_URI[sha256sum] = "74744e00420856cfc8049fa3b3a55e57a116994226a498ef56801bc9492df36b"
