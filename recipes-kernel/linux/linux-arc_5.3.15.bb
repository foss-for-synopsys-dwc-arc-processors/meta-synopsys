require linux-arc.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=bbea815ee2795b2f4230826c0c6b8814"
SRC_URI[md5sum] = "3919149d6dfd122f24570c873bce951d"
SRC_URI[sha256sum] = "cec8aaea89feac4a3555f1e4b90000244ff7c5e7640db242a7de796a006d1197"

