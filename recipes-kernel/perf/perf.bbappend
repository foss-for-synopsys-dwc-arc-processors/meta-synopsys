# libunwind is not yet ported for ARC
PACKAGECONFIG_remove_arc = "libunwind"
