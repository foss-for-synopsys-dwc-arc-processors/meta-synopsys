FILESEXTRAPATHS_append := "${THISDIR}/files:"
SRC_URI_append = " \
        file://0001-spa-plugins-add-ARC-cpu.patch \
"
