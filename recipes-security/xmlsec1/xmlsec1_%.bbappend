FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append += "\
    file://0001-Remove-host-usr-lib-and-usr-include-usage.patch; \
"
