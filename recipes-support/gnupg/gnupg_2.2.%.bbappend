EXTRA_OECONF_append = " ac_cv_have_decl_sys_siglist=no"
