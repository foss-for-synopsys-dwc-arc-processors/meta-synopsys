EXTRA_OECONF_remove_libc-uclibc = "--enable-doc"
EXTRA_OECONF_append_libc-uclibc = " --disable-doc"
LDFLAGS_remove_libc-uclibc = " -luargp"
