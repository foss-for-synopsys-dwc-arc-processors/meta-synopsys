FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append += "\
    file://0001-Add-support-for-the-ARC-architecture.patch; \
"

